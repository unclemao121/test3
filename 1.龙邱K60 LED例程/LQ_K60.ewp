# IAR project LQ_K60.ewp, settings and files
configuration MK60DN (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60DN; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Drive
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K60.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\linker\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK60FX (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.FPU2: 4
  ICCARM.CCDefines: MK60FX; _DLIB_FILE_DESCRIPTOR
  ILINK.IlinkIcfFile: src\Project_Setting\linker\PFXflash.icf
  group Drive
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group Project_Setting/Startup
    src/Project_Setting/Startup/: fsl_device_registers.h start.c startup_MK60D10.s
    src/Project_Setting/Libs/: MK60N512VMD100.h
  group User
    src/User/: include.h IRQ_Handler.c main.c
  group User/LED
    src/User/: LQ_LED.c LQ_LED.h
